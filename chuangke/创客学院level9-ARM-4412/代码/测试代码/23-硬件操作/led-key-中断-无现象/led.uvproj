# Keil uVision project led.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: led
  BeforeCompile: make
  group Source Group 1
    ./: led.s main.c
