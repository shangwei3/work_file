# Keil uVision project test.uvproj, settings and files
target test (ARM-GNU)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: test
  AfterMake: make
  group src
    ./: test.s main.c
