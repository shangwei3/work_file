# Keil uVision project led.uvproj, settings and files
target led (ARM-GNU)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: led
  AfterMake: E:\华清远见\第三期\ARM\16071\第一天\ARM开发环境搭建(软件仿真)\工具软件\make工具\make-64.exe
  group Source Group 1
    ./: led.s main.c
