# Keil uVision project uart.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: uart
  AfterMake: D:\software\yagarto_tool\yagarto-tools-20100703\bin\make.exe
  group Source Group 1
    ./: uart.s main.c
