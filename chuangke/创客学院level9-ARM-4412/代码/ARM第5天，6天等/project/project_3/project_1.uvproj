# Keil uVision project project_1.uvproj, settings and files
target test1 (ARM-GNU)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: project_1
  AfterMake: make
  group src
    ./: start.s main.c
